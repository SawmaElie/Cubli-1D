# Keil uVision project Cubli-1D.uvprojx, settings and files
target Cubli-1D (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Cubli-1D +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F303xC
  c include: ../Core/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../Drivers/CMSIS/Include;..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f303xc.s
  group Application/User/Core
    ../Core/Src/: encoder_control.c filters.c gyro.c jump_control.c pwm_control.c main.c gpio.c i2c.c tim.c stm32f3xx_it.c stm32f3xx_hal_msp.c
    ../Core/Inc/: encoder_control.h filters.h gyro.h jump_control.h pwm_control.h
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_exti.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
software components: CMSIS:CORE 4.3.0
